Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Duplex_MEP_20121207 - Electrical.ifc
Time: 2012-12-18T09:10:15
Written by: Autodesk Revit 2013
Made in: 20121003_2115(x64)

# IfcProject, 0001
LongName: Duplex Apartment; Phase: Project Status

# IfcSite, Default
RefLatitude: 41, 52, 27, 843933; RefLongitude: -87, -38, -21, -828002; RefElevation: 0 ft

# IfcBuilding, XYZ
LongName: XYZ
Pset_BuildingCommon - BuildingID: Duplex MEP; OccupancyType: Residential; YearOfConstruction: 2011 - 2012; NumberOfStoreys: 3
Text - Reference: Type XYZ; Heat: 250; Water: 300; BuildingID: Duplex MEP; SprinklerProtectionAutomatic: FALSE; YearOfLastRefurbishment: 0; Electricity: 500; FireProtectionClass: Class 1; IsPermanentID: FALSE; Steam: 100; YearOfConstruction: 2011 - 2012; IsLandmarked: FALSE; ConstructionMethod: New Construction; OccupancyType: Residential; Fuel: 750; SprinklerProtection: FALSE; GrossPlannedArea: 312; NumberOfStoreys: 2; NetPlannedArea: 500
Identity Data - Author: ABC DEF; Building Name: XYZ; Organization Description: IT; Organization Name: Company XYZ
Other - Project Number: 0001; Project Name: Duplex Apartment; Project Status: Project Status; Category Description: Duplex; Project Issue Date: Issue Date; Client Name: Owner; Category Code: 11-16 21 11; Project Address: 12345 Right Way Chicago, IL 60601

# IfcBuildingStorey (3)
In: XYZ
Constraints - Elevation Base: 0
Graphics - Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no
Identity Data - Building Story: yes; Structural: no
Dimensions - Computation Height: 3.93701 ft
Name | LongName = Name | Elevation (ft) = Constraints, Elevation (ft) | Category Code
Level 1 | Level 1 | 0 | Floor
Level 2 | Level 2 | 10.1706 | Floor
Roof | Roof | 19.685 | Roof

# IfcSpace, R301
In: Roof
Description: N/A; LongName: Roof; InteriorOrExteriorSpace: INTERNAL
GSA Space Areas - GSA BIM Area: 1568.54 ft2
Constraints - Limit Offset: 9.84252 ft; Upper Limit: Level: Roof; Level: Level: Roof; Base Offset: 0 ft
Identity Data - Ceiling Finish: N/A; Department: N/A; Comments: N/A; OmniClass Table 13 Category: Other General Facility Service Spaces; Name: Roof; Wall Finish: N/A; Base Finish: N/A; Occupancy: N/A; Number: R301; Floor Finish: N/A
Other - FireAlarmZoneName: Roof FireAlarmZoneName; WallCovering: N/A; LoadCapacity: N/A; LightingZoneName: Roof LightingZoneName; FloorCovering: N/A; Category Code: 13-81 11 99; HistoricPreservationZoneName: Roof HistoricPreservationZoneName; CirculationZoneName: Roof CirculationZoneName; Category Description: Other General Facility Service Spaces; OccupancyZoneName: Roof OccupancyZoneName; VentilationZoneName: Roof VentilationZoneName; CeilingCovering: N/A; RoomTag: N/A
Phasing - Phase: New Construction
Dimensions - Computation Height: 3.93701 ft; Area: 1568.54 ft2; Unbounded Height: 9.84252 ft; Perimeter: 169.068 ft; Volume: 15438.3 ft3
Pset_SpaceCommon - Reference: Roof R301; CeilingCovering: N/A; WallCovering: N/A; FloorCovering: N/A

# IfcBuildingElementProxy: Telophone Outlet (4)
Constraints - Default Elevation: 1.50919 ft; Offset: 0 ft; Host: Linked Revit Model : Duplex_A_2013.rvt
Other - ModelLabel: N/A; WarrantyDurationParts: N/A; Grade: N/A; ModelReference: N/A; Features: N/A; Color: N/A; AssetAccountingType: FIXED; Size: N/A; ProductionYear: N/A; SustainabilityPerformance: N/A; NominalWidth: N/A; WarrantyGuarantorParts: N/A; WarrantyDurationLabor: N/A; Finish: N/A; Constituents: N/A; NominalLength: N/A; CodePerformance: N/A; ReplacementCost: N/A; Shape: N/A; WarrantyGuarantorLabor: N/A; WarrantyDescription: N/A; AccessibilityPerformance: N/A; ExpectedLife: N/A; Material: N/A; NominalHeight: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; Schedule Level: Level: Level 1; BarCode: N/A; AssetIdentifier: N/A; TagNumber: N/A; SerialNumber: N/A
Identity Data - Manufacturer: N/A; OmniClass Number: 23.85.50.14; OmniClass Title: Telephone and Intercommunication Equipment
Phasing - Phase Created: New Construction
Electrical - Loads - Panel: TTB1
Pset_BuildingElementProxyCommon - Reference: Telophone Outlet
Name (M_Telephone Outlet:Telophone Outlet:Telophone Outlet:...) | In | Elevation (ft) | Circuit Number
611904 | Level 1 | 3.56692 | 1
611989 | Level 1 | 3.7284 | 2
612214 | Level 2 | 12.6245 | 1
612319 | Level 2 | 12.6057 | 2

# IfcDistributionControlElement: 400x475, M_Fire Alarm Control Panel:400x475:Fire Alarm Panel:617780
In: Level 1
Type - ElementType: 400x475; PredefinedType: USERDEFINED; Classification:  (UniFormat)
Constraints - Default Elevation: 3.93701 ft; Host: Linked Revit Model : Duplex_A_2013.rvt; Elevation: 3.93701 ft
Dimensions - Projection: 0.089895 ft; Height: 1.5584 ft; Depth: 0.364173 ft; Width: 1.31234 ft
Identity Data - Model: SKU VEN3-GEC-6001020; Manufacturer: UTC FIRE & SECURITY GE; OmniClass Title: Alarm Panels; OmniClass Number: 23.85.30.21.11.14; Mark: 1
Other - PowerFactor: 0.90; WarrantyGuarantorLabor: N/A; ConductorFunction: L3; NominalHeight: N/A; ReplacementCost: N/A; Features: N/A; Finish: N/A; Grade: N/A; Material: N/A; NumberOfPoles: 1; InsulationStandardClass: NOTKNOWN; RatedCurrent: 50; SustainabilityPerformance: N/A; NominalWidth: N/A; IP_Code: 54; CodePerformance: N/A; ModelReference: SKU VEN3-GEC-6001020; ModelLabel: N/A; AccessibilityPerformance: N/A; WarrantyDescription: N/A; Shape: N/A; WarrantyDurationLabor: N/A; IsMain: TRUE; Constituents: N/A; Size: N/A; RatedVoltage: 240; WarrantyGuarantorParts: N/A; NominalFrequencyRange: 50-60; ProductionYear: N/A; WarrantyDurationParts: N/A; NominalLength: N/A; ExpectedLife: N/A; HasProtectiveEarth: FALSE; AssetAccountingType: FIXED; Color: N/A; IsSkilledOperator: TRUE; Status: NEW; SerialNumber: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; TagNumber: N/A; Schedule Level: Level: Level 1; BarCode: N/A; AssetIdentifier: N/A
General - Panel Name: Fire Alarm Panel
Phasing - Phase Created: New Construction
Text - Reference: Type E

# IfcDistributionControlElement: Thermostat (2)
In: Level 1
Type - ElementType: Thermostat; PredefinedType: TWOPOSITION; Classification:  (UniFormat)
Other - AssetIdentifier: N/A; InstallationDate: N/A; BarCode: N/A; WarrantyStartDate: N/A; Status: N/A; Schedule Level: Level: Level 1; SerialNumber: N/A; TagNumber: N/A; InsulationStandardClass: NOTKNOWN; RatedVoltage: 24; ConductorFunction: L1; PowerFactor: 0.85; IP_Code: 54; WarrantyDescription: N/A; Constituents: N/A; AccessibilityPerformance: N/A; Finish: N/A; Features: N/A; WarrantyGuarantorLabor: N/A; NominalWidth: N/A; CodePerformance: N/A; RatedCurrent: 15; SustainabilityPerformance: N/A; WarrantyDurationParts: N/A; WarrantyGuarantorParts: N/A; NominalFrequencyRange: 60; ReplacementCost: N/A; Shape: N/A; NominalHeight: N/A; NumberOfPoles: 1; AssetAccountingType: FIXED; HasProtectiveEarth: TRUE; Size: N/A; ExpectedLife: N/A; ProductionYear: N/A; Material: N/A; Color: N/A; ModelLabel: N/A; NominalLength: N/A; WarrantyDurationLabor: N/A; ModelReference: N/A; Grade: N/A
Constraints - Host: Linked Revit Model : Duplex_A_2013.rvt; Default Elevation: 3.93701 ft
Electrical - Loads - Circuit Number: <unnamed>
Phasing - Phase Created: New Construction
Dimensions - Width: 0.334646 ft; Height: 0.0721785 ft; Length: 0.364173 ft
Identity Data - Model: TH3110D1008; OmniClass Number: 23.85.80.11.24; Manufacturer: Grainger; OmniClass Title: Environmental Controls; Label: T
Name (M_Thermostat:Thermostat:Thermostat:...) | Elevation (ft) | Mark
610678 | 4.34323 | 5
610734 | 4.26997 | 6

# IfcEnergyConversionDevice: 147 kW (2)
In: Level 2
Type - ElementType: 147 kW; PredefinedType: WATER; Classification:  (UniFormat)
Other - InstallationDate: N/A; SerialNumber: N/A; AssetIdentifier: N/A; BarCode: N/A; WarrantyStartDate: N/A; TagNumber: N/A; NominalFrequencyRange: 50; Grade: N/A; Constituents: N/A; RatedVoltage: 230; Shape: N/A; HasProtectiveEarth: TRUE; WarrantyDurationParts: N/A; Size: N/A; Material: N/A; RatedCurrent: 30; Features: N/A; NominalLength: 14"; WarrantyGuarantorLabor: N/A; Finish: N/A; NominalHeight: 33"; PowerFactor: 0.26; Vent Box Radius: 0.416667 ft; NumberOfPoles: 3; WarrantyDurationLabor: N/A; ExpectedLife: N/A; ReplacementCost: N/A; AccessibilityPerformance: N/A; NominalWidth: 17"; ConductorFunction: L1; SustainabilityPerformance: N/A; Boiler Radius: 1.00066 ft; Boiler Top Radius: 0.918635 ft; WarrantyDescription: N/A; AssetAccountingType: FIXED; Radius 1: 0.750656 ft; IP_Code: 52; ModelLabel: Linea HE; WarrantyGuarantorParts: N/A; CodePerformance: N/A; Color: N/A; ProductionYear: N/A; ModelReference: Linea HE
Phasing - Phase Created: New Construction
Constraints - Offset: 0.062336 ft; Host: Level : Level 2; Level: Level: Level 2
Mechanical - Water Flow: 0; System Classification: Hydronic Supply,Hydronic Return,Other,Power,Exhaust Air; Exhaust Air Flow: 0; Water Pressure Drop: 99974.4; Exhaust Air Pressure Drop: 0; Gas Flow: 0.0155385; Input Heat: 3465979; Output Heat: 2949311
Electrical - Loads - Circuit Number: 9,11,13; Apparent Load: 1571531
Identity Data - OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Manufacturer: Vokera; Model: Linea HE
Electrical - Load Classification: Heating; Number of Poles: 3; Voltage: 2238.89
Dimensions - Gas Radius: 0.0410105; Hot Water Diameter: 0.131234; Cold Water Diameter: 0.131234; Vent Radius: 0.410105; Vent Diameter: 0.82021; Boiler Diameter: 2.00131 ft; Gas Diameter: 0.082021; Hot Water Radius: 0.0656168; Vent Box Diameter: 0.833333 ft; Electrical Box Width: 0.308399 ft; Boiler Height: 3.16601 ft; Boiler Top Diameter: 1.83727 ft; Electrical Box Height: 0.66601 ft; Cold Water Radius: 0.0656168; Vent Box Height: 0.334646 ft; Electrical Box Length: 0.66601 ft
Name (M_Hot Water Boiler - 59-440 kW:147 kW:147 kW:...) | System Name | Mark | Panel
530072 | Unit A Hydronic Supply In,Unit A Hydronic Return,Unit A Natural Gas,Unit A Mechanical Exhaust Air | 26 | Unit A Panelboard
557516 | Unit B Hydronic Supply In,Unit B Hydronic Return,Unit B Natural Gas,Unit B Mechanical Exhaust Air | 64 | Unit B Panelboard

# IfcFlowController: 400 A (2)
In: Level 1
Type - ElementType: 400 A; PredefinedType: USERDEFINED; Classification:  (UniFormat)
Electrical - Circuiting - Circuit Naming: 1; Electrical Data: 208 V/3-0 VA; Mains: 100; Distribution System: Distribution System: 120/208 Wye; Max #1 Pole Breakers: 24; Number of Wires: 4; Number of Phases: 3
Electrical - Loads - Lighting - Dwelling Unit Connected: 9687.52; Lighting - Dwelling Unit Demand Factor: 1; HVAC Demand Factor: 1; Heating Connected Current: 405.255; Receptacle Demand Factor: 1; HVAC Connected: 5166.68; Heating Connected: 1571531; Appliance - Dwelling Unit Estimated Demand: 5834.04; HVAC Estimated Demand: 5166.68; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Estimated Demand: 9687.52; HVAC Connected Current: 1.33235; Heating Demand Factor: 1; Total Demand Factor: 1; Heating Estimated Demand: 1571531; Appliance - Dwelling Unit Demand Factor: 1; Heating Estimated Demand Current: 405.255; Appliance - Dwelling Unit Connected Current: 1.50444; Appliance - Dwelling Unit Estimated Demand Current: 1.50444; Other Connected: 0; Lighting - Dwelling Unit Estimated Demand Current: 2.49815; Lighting - Dwelling Unit Connected Current: 2.49815; Other Estimated Demand: 0; HVAC Estimated Demand Current: 1.33235; Appliance - Dwelling Unit Connected: 5834.04; Other Connected Current: 0
General - Enclosure: Type 1; Mounting: Recessed
Constraints - Host: Orphaned; Offset: 0 ft; Elevation: 0 ft; Default Elevation: 3.93701 ft
Other - SerialNumber: N/A; AssetIdentifier: N/A; Status: NEW; TagNumber: N/A; BarCode: N/A; WarrantyStartDate: N/A; InstallationDate: N/A; Features: N/A; WarrantyGuarantorLabor: N/A; NominalLength: N/A; SustainabilityPerformance: N/A; ModelReference: NQ; Finish: N/A; WarrantyDurationParts: N/A; IsMain: FALSE; Size: N/A; ModelLabel: N/A; ReplacementCost: N/A; ConductorFunction: L3; Shape: N/A; WarrantyGuarantorParts: N/A; ExpectedLife: N/A; InsulationStandardClass: NOTKNOWN; RatedCurrent: 600; RatedVoltage: 240; NominalWidth: N/A; WarrantyDescription: N/A; AccessibilityPerformance: N/A; IsSkilledOperator: TRUE; HasProtectiveEarth: TRUE; AssetAccountingType: FIXED; Color: N/A; NominalHeight: N/A; Material: N/A; ProductionYear: N/A; NumberOfPoles: 1; PowerFactor: 0.85; WarrantyDurationLabor: N/A; NominalFrequencyRange: 50-60; IP_Code: 14; CodePerformance: N/A; Constituents: N/A; Grade: N/A
Text - Reference: Type E
Phasing - Phase Created: New Construction
Dimensions - Height: 4.16667 ft; 30 Circuit Height: 4.16667 ft; 24 Circuit Height: 4.16667 ft; Depth: 0.479331 ft; 42 Circuit Height: 4.41667 ft; 12 Circuit Height: 4.16667 ft; Width: 1.66667 ft
Electrical - Load Classification: Other
Identity Data - OmniClass Number: 23.80.30.11.17; Model: NQ; Manufacturer: NQ, NF, I-Line® and QMB Panelboard Products; OmniClass Title: Distribution Boards and Control Panels
Name (M_Lighting and Appliance Panelboard - 208V MLO:400 A:...) | Mark | Total Estimated Demand Current = Total Connected Current | Total Estimated Demand = Total Connected | Receptacle Estimated Demand = Receptacle Connected | Current Phase B | Current Phase A | Apparent Load Phase A | Receptacle Connected Current = Receptacle Estimated Demand Current | Apparent Load Phase B | Apparent Load Phase C | Current Phase C | Panel Name
Unit A Panelboard:575479 | 8 | 422.582 | 1638719 | 46500.1 | 423.833 | 427.735 | 551540 | 11.9911 | 546499 | 540307 | 418.301 | Unit A Panelboard
Unit B Panelboard:575481 | 9 | 422.082 | 1636782 | 44562.6 | 417.661 | 433.17 | 559295 | 11.4915 | 539263 | 537853 | 416.402 | Unit B Panelboard

# IfcFlowController: Smoke Detector (6)
Type - ElementType: Smoke Detector; PredefinedType: USERDEFINED; Classification:  (UniFormat)
Other - Status: NEW; SerialNumber: N/A; InstallationDate: N/A; WarrantyStartDate: N/A; TagNumber: N/A; AssetIdentifier: N/A; BarCode: N/A; Schedule Level: Level: Level 1; ReplacementCost: N/A; AssetAccountingType: FIXED; Color: N/A; ModelReference: 480(C); AccessibilityPerformance: N/A; Shape: N/A; Constituents: N/A; SustainabilityPerformance: N/A; ExpectedLife: N/A; ModelLabel: N/A; Material: N/A; NominalHeight: N/A; WarrantyDurationParts: N/A; NominalLength: N/A; WarrantyGuarantorParts: N/A; Size: N/A; WarrantyDurationLabor: N/A; WarrantyGuarantorLabor: N/A; Features: N/A; Finish: N/A; CodePerformance: N/A; Grade: N/A; NominalWidth: N/A; WarrantyDescription: N/A; ProductionYear: N/A
Electrical - Loads - Panel: Fire Alarm Panel
Phasing - Phase Created: New Construction
Constraints - Offset: 0 ft; Host: Linked Revit Model : Duplex_A_2013.rvt; Default Elevation: 3.93701 ft
Text - Reference: Type C
Identity Data - Manufacturer: FIREX; Smoke Alarm; OmniClass Title: Smoke Detectors; Model: 480(C); OmniClass Number: 23.85.30.21.11.11.11
Dimensions - Head Depth: 0.124672 ft; Head Radius: 0.167323 ft; Base Radius: 0.229659 ft; Base Depth: 0.167323 ft; Head Small Radius: 0.124672 ft
Name (M_Smoke Detector:Smoke Detector:Smoke Detector:...) | In | Circuit Number | Elevation (ft)
610280 | Level 1 | 1 | 8.53018
610319 | Level 2 | 1 | 18.7008
610426 | Level 2 | 2 | 18.7008
610469 | Level 2 | 2 | 18.7008
610482 | Level 2 | 1 | 18.7008
610550 | Level 1 | 2 | 8.53018

# IfcFlowMovingDevice: 3.9 LPS - 0.8 Meter Head (2)
In: Level 2
Type - ElementType: 3.9 LPS - 0.8 Meter Head; PredefinedType: CIRCULATOR; Classification:  (UniFormat)
Other - WarrantyStartDate: N/A; TagNumber: N/A; SerialNumber: N/A; BarCode: N/A; InstallationDate: N/A; AssetIdentifier: N/A; Constituents: N/A; Length 4: 0.07004 ft; Shape: N/A; Outside Radius 1: 0.301837 ft; Features: N/A; Grade: N/A; ExpectedLife: N/A; ModelReference: N/A; WarrantyDurationParts: N/A; PowerFactor: 0.13; Outside Radius 2: 0.280512 ft; WarrantyDurationLabor: N/A; WarrantyDescription: N/A; Size: N/A; ConductorFunction: L1; Radius 3: 0.185144 ft; Finish: N/A; Outside Radius 4: 0.101811 ft; SustainabilityPerformance: N/A; AccessibilityPerformance: N/A; NominalWidth: N/A; Radius 1: 0.259678 ft; Color: N/A; AssetAccountingType: FIXED; NominalLength: N/A; CodePerformance: N/A; NumberOfPoles: 1; WarrantyGuarantorParts: N/A; RatedVoltage: 230; RatedCurrent: 30; ModelLabel: N/A; NominalFrequencyRange: 60; Radius 2: 0.238845 ft; WarrantyGuarantorLabor: N/A; IP_Code: 56; ProductionYear: N/A; Material: N/A; ReplacementCost: N/A; NominalHeight: N/A; Flange Radius: 0.167323 ft; HasProtectiveEarth: TRUE
Electrical - Loads - Circuit Number: 10,12,14; Apparent Load: 5834.04
Mechanical - System Classification: Undefined,Power; RPM: 1450
Constraints - Host: Level : Level 2; Level: Level: Level 2
Phasing - Phase Created: New Construction
Identity Data - OmniClass Number: 23.60.30.21; OmniClass Title: Pumps; Manufacturer: Shanghai Aoli Pump Manufacture Co., Ltd.; Model: A1B2C3
Electrical - Number of Poles: 3; Voltage: 2238.89; Load Classification: Appliance - Dwelling Unit
Dimensions - Housing Width: 0.498688 ft; Suction Outside Diameter: 0.172244; Length 3: 0.203622 ft; Outside Diameter 4: 0.203622 ft; Length 2: 1.13123 ft; Outside Diameter 2: 0.561024 ft; Suction Outside Radius: 0.086122; Flange Height: 0.426509 ft; Length 1: 1.41404 ft; Discharge Nominal Radius: 0.0656168; Suction Nominal Radius: 0.0656168; Flange Diameter: 0.334646 ft; Outside Diameter 1: 0.603675 ft; Discharge Nominal Diameter: 0.131234; Suction Nominal Diameter: 0.131234
Name (M_Inline Pump - Circulator:3.9 LPS - 0.8 Meter Head:3.9 LPS - 0.8 Meter Head:...) | Panel | System Name | Offset (ft) | Mark
550094 | Unit A Panelboard | Unit A Hydronic Supply In | 0.290846 | 62
580717 | Unit B Panelboard | Unit B Hydronic Supply In | 0.31167 | 74

# IfcFlowMovingDevice: 991-1905 LPS (2)
In: R301
Type - ElementType: 991-1905 LPS; PredefinedType: CENTRIFUGALAIRFOIL; Classification:  (UniFormat)
Constraints - Host: Linked Revit Model : Duplex_A_2013.rvt; Elevation: 21.1844 ft; Default Elevation: 3.93701 ft
Other - InstallationDate: N/A; BarCode: N/A; TagNumber: N/A; SerialNumber: N/A; Schedule Level: Level: Level 1; WarrantyStartDate: N/A; AssetIdentifier: N/A; HasProtectiveEarth: TRUE; Finish: N/A; RatedVoltage: 240; Material: N/A; RatedCurrent: 30; Radius 1: 0.492126 ft; Shape: N/A; AssetAccountingType: FIXED; SustainabilityPerformance: N/A; Half Exhaust Inlet Height: 0.410105 ft; ExpectedLife: N/A; Radius 2: 0.524934 ft; NominalFrequencyRange: 60; WarrantyGuarantorParts: N/A; CodePerformance: N/A; ModelLabel: N/A; ProductionYear: N/A; Color: N/A; Grade: N/A; AccessibilityPerformance: N/A; NominalWidth: N/A; NominalLength: N/A; PowerFactor: 0.15; WarrantyDescription: N/A; ConductorFunction: L1; Constituents: N/A; Diameter 2: 1.04987 ft; IP_Code: 54; NumberOfPoles: 1; Size: N/A; Half Outlet Radius: 0.410105 ft; NominalHeight: N/A; ModelReference: DCLH; WarrantyDurationParts: N/A; Features: N/A; ReplacementCost: N/A; WarrantyGuarantorLabor: N/A; WarrantyDurationLabor: N/A; Diameter 1: 0.984252 ft
Mechanical - External Static Presure: 37.7952; System Classification: Exhaust Air,Power; RPM: 800
Electrical - Loads - Circuit Number: 15,17,19; Apparent Load: 5166.68
Phasing - Phase Created: New Construction
Dimensions - Base Width: 1.31234 ft; Fan Diameter: 1.31234 ft; Fan Height: 0.656168 ft; Overall Height: 0.984252 ft; Outlet Height: 0.82021; Outlet Width: 0.82021; Fan Radius: 0.656168 ft; Cap Diameter: 0.918635 ft; Cap Radius: 0.459318 ft
Identity Data - OmniClass Number: 23.75.35.17.27; Model: DCLH; Manufacturer: Twin City; OmniClass Title: Centrifugal Fans
Electrical - Load Classification: HVAC; Voltage: 2238.89; Number of Poles: 3
Name (M_Centrifugal Fan - Rooftop - Upblast:991-1905 LPS:991-1905 LPS:...) | Air Flow | System Name | Mark | Panel
602113 | 17.6573 | Unit A Mechanical Exhaust Air | 75 | Unit A Panelboard
602396 | 67.2744 | Unit B Mechanical Exhaust Air | 76 | Unit B Panelboard

# IfcFlowTerminal: 100W - 120V (6)
Type - ElementType: 100W - 120V; PredefinedType: USERDEFINED; Classification: D5020220 Lighting - Incandescent (UniFormat)
Material: Glass - Frosted
Other - SecurityLightingType: OTHER; FixtureHeight: 0; SelfTestFunction: NONE; SerialNumber: N/A; AssetIdentifier: N/A; TagNumber: N/A; WarrantyStartDate: N/A; Status: NEW; BarCode: N/A; InstallationDate: N/A; MaximumPlenumSensibleLoad: 0; ReplacementCost: N/A; AccessibilityPerformance: N/A; InsulationStandardClass: NOTKNOWN; RatedCurrent: 20; SustainabilityPerformance: N/A; RatedVoltage: 120; NumberOfSources: 1; ExpectedLife: N/A; Color: N/A; WarrantyDescription: N/A; ModelReference: N/A; WarrantyGuarantorLabor: N/A; NominalLength: N/A; Features: N/A; Size: N/A; NominalHeight: N/A; TotalWattage: 100; SensibleLoadToRadiant: 0; IP_Code: 54; NumberOfPoles: 1; WarrantyGuarantorParts: N/A; NominalWidth: N/A; ModelLabel: N/A; MaintenanceFactor: 3; PowerFactor: 0.28; ProductionYear: N/A; Finish: N/A; AssetAccountingType: FIXED; CodePerformance: N/A; Constituents: N/A; Shape: N/A; LightFixturePlacingType: WALL; WarrantyDurationLabor: N/A; MaximumSpaceSensibleLoad: 0; ConductorFunction: L1; HasProtectiveEarth: TRUE; Material: N/A; WarrantyDurationParts: N/A; LightFixtureMountingType: OTHER; Grade: N/A; NominalFrequencyRange: 60
Text - Reference: Type A
Constraints - Elevation: 0 ft; Default Elevation: 6.2336 ft
Phasing - Phase Created: New Construction
Electrical - Lighting - Calculate Coefficient of Utilization: no
Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
Photometrics - Light Source Definition (family): Point+HemiSpherical; Initial Intensity: 0; Color Filter: 16777215; Dimming Lamp Color Temperature Shift: 0; Light Loss Factor: 0; Initial Color: 0
Materials and Finishes - Shade Material: Glass - Frosted
Dimensions - Radius: 0.656168 ft; Light Source Symbol Size: 0.656168 ft
Electrical - Ballast Number of Poles: 1; Load Classification: Lighting - Dwelling Unit; Ballast Voltage: 1291.67; Lamp: R-30
Identity Data - Manufacturer: Hampton Bay; OmniClass Title: General Luminaries, Non Directional; Model: Y32012-42; Assembly Description: Lighting - Incandescent; Assembly Code: D5020220; OmniClass Number: 23.80.70.11.11
Electrical - Loads - Apparent Load: 1076.39
Name (M_Sconce Light - Sphere:100W - 120V:100W - 120V:...) | In | Circuit Number | Panel | Host | Mark
575376 | Level 1 | 2 | Unit A Panelboard | Orphaned | 5
575378 | Level 1 | 4 | Unit B Panelboard | Orphaned | 6
575388 | Level 2 | 8 | Unit A Panelboard | Orphaned | 13
575390 | Level 2 | 6 | Unit B Panelboard | Orphaned | 14
575488 | Level 1 | 1 | Unit A Panelboard | M_Duplex Receptacle : Duplex Receptacle | 15
575490 | Level 1 | 3 | Unit B Panelboard | M_Duplex Receptacle : Duplex Receptacle | 16

# IfcFlowTerminal: 150W - 120V (8)
Type - ElementType: 150W - 120V; PredefinedType: USERDEFINED; Classification: D5020220 Lighting - Incandescent (UniFormat)
Material: Metal - Chrome, Glass - Frosted
Text - Reference: Type B
Other - SelfTestFunction: NONE; BarCode: N/A; TagNumber: N/A; FixtureHeight: 0; SecurityLightingType: OTHER; SerialNumber: N/A; AssetIdentifier: N/A; WarrantyStartDate: N/A; Status: NEW; InstallationDate: N/A; ReplacementCost: N/A; ConductorFunction: L1; AssetAccountingType: FIXED; NominalHeight: N/A; WarrantyGuarantorLabor: N/A; Shape: N/A; NominalWidth: N/A; ModelLabel: N/A; CodePerformance: N/A; MaintenanceFactor: 3; MaximumSpaceSensibleLoad: 0; MaximumPlenumSensibleLoad: 0; ExpectedLife: N/A; InsulationStandardClass: NOTKNOWN; ModelReference: 5601; NumberOfPoles: 1; HasProtectiveEarth: TRUE; RatedVoltage: 120; WarrantyDurationParts: N/A; NominalLength: N/A; WarrantyGuarantorParts: N/A; RatedCurrent: 20; IP_Code: 54; Features: N/A; Finish: N/A; Size: N/A; ProductionYear: N/A; NumberOfSources: 1; Material: N/A; WarrantyDurationLabor: N/A; LightFixtureMountingType: SUSPENDED; TotalWattage: 60; LightFixturePlacingType: CEILING; Constituents: N/A; Grade: N/A; WarrantyDescription: N/A; SensibleLoadToRadiant: 0; NominalFrequencyRange: 60; AccessibilityPerformance: N/A; PowerFactor: 0.28; Color: N/A; SustainabilityPerformance: N/A
Electrical - Lighting - Calculate Coefficient of Utilization: no
Constraints - Elevation: 0 ft; Host: Orphaned; Default Elevation: 3.93701 ft
Phasing - Phase Created: New Construction
Electrical - Circuiting - Electrical Data: 120 V/1-150 VA
Identity Data - Assembly Description: Lighting - Incandescent; Model: 5601; Manufacturer: Kandelite Co.; OmniClass Number: 23.80.70.11.11; Assembly Code: D5020220; OmniClass Title: General Luminaries, Non Directional
Photometrics - Initial Color: 0; Initial Intensity: 0; Dimming Lamp Color Temperature Shift: 0; Light Loss Factor: 0; Light Source Definition (family): Point+Spherical; Color Filter: 16777215
Dimensions - Light Source Symbol Size: 0.246063 ft; Drop From Ceiling: 2.21457 ft
Electrical - Lamp: A-21; Load Classification: Lighting - Dwelling Unit; Ballast Number of Poles: 1; Ballast Voltage: 1291.67
Materials and Finishes - Pendant Material: Glass - Frosted; Ceiling Mount Material: Metal - Chrome
Electrical - Loads - Apparent Load: 1614.59
Name (M_Pendant Light - Hemisphere:150W - 120V:150W - 120V:...) | In | Mark | Panel | Circuit Number
575380 | Level 1 | 7 | Unit A Panelboard | 4
575382 | Level 1 | 8 | Unit B Panelboard | 1
575383 | Level 2 | 9 | Unit B Panelboard | 8
575385 | Level 2 | 10 | Unit A Panelboard | 5
575386 | Level 2 | 11 | Unit A Panelboard | 7
575387 | Level 2 | 12 | Unit B Panelboard | 5
575505 | Level 2 | 17 | Unit A Panelboard | 6
575508 | Level 2 | 18 | Unit B Panelboard | 7

# IfcFlowTerminal: 760 x 400 x 450mm (2)
In: Level 1
Type - ElementType: 760 x 400 x 450mm; PredefinedType: MICROWAVE; Classification:  (UniFormat)
Material: Glass, Laminate - Ivory, Matte
Materials and Finishes - Material: Laminate - Ivory, Matte
Identity Data - Manufacturer: SAMSUNG; Model: KBMS1454S; OmniClass Title: Food Cooking Equipment; OmniClass Number: 23.40.40.14.17
Other - WarrantyGuarantorLabor: N/A; Material: N/A; RatedCurrent: 30; PowerFactor: 0.28; Color: N/A; NumberOfPoles: 1; ProductionYear: N/A; WarrantyGuarantorParts: N/A; NominalHeight: N/A; CodePerformance: N/A; ModelReference: KBMS1454S; WarrantyDurationLabor: N/A; Finish: N/A; SustainabilityPerformance: N/A; ConductorFunction: L1; Constituents: N/A; WarrantyDurationParts: N/A; ReplacementCost: N/A; AssetAccountingType: FIXED; RatedVoltage: 120; Grade: N/A; ModelLabel: N/A; WarrantyDescription: N/A; HasProtectiveEarth: TRUE; Size: N/A; NominalFrequencyRange: 60; NominalWidth: N/A; AccessibilityPerformance: N/A; IP_Code: 54; Shape: N/A; Features: N/A; InsulationStandardClass: NOTKNOWN; ExpectedLife: N/A; NominalLength: N/A; BarCode: N/A; SerialNumber: N/A; WarrantyStartDate: N/A; Status: N/A; InstallationDate: N/A; AssetIdentifier: N/A; TagNumber: N/A
Dimensions - Width: 2.49344 ft; Depth: 1.31234 ft; Height: 1.47638 ft
Phasing - Phase Created: New Construction
Constraints - Host: Level : Level 1; Offset: 2.0853 ft; Level: Level: Level 1
Name (M_Microwave:760 x 400 x 450mm:760 x 400 x 450mm:...) | Mark
615600 | 7
615603 | 8

# IfcFlowTerminal: 760 x 650mm (2)
In: Level 1
Type - ElementType: 760 x 650mm; PredefinedType: ELECTRICCOOKER; Classification:  (UniFormat)
Material: Metal - Painted Finish - Ivory, Matte, Metal - Chrome, Glass
Other - AssetIdentifier: N/A; TagNumber: N/A; WarrantyStartDate: N/A; InstallationDate: N/A; BarCode: N/A; Status: N/A; SerialNumber: N/A; Finish: N/A; InsulationStandardClass: NOTKNOWN; Shape: N/A; AccessibilityPerformance: N/A; Range Material: Metal - Painted Finish - Ivory, Matte; WarrantyDurationParts: N/A; Material: N/A; AssetAccountingType: FIXED; Color: N/A; HasProtectiveEarth: TRUE; ExpectedLife: N/A; PowerFactor: 0.26; ProductionYear: N/A; NominalLength: N/A; Grade: N/A; NominalWidth: N/A; Constituents: N/A; ConductorFunction: L1; RatedVoltage: 240; NominalFrequencyRange: 60; Size: N/A; RatedCurrent: 60; ReplacementCost: N/A; CodePerformance: N/A; IP_Code: 54; NumberOfPoles: 1; Features: N/A; WarrantyDurationLabor: N/A; NominalHeight: N/A; Width: 2.49344 ft; WarrantyGuarantorLabor: N/A; Depth: 2.13255 ft; WarrantyGuarantorParts: N/A; Burner Material: Metal - Chrome; ModelLabel: N/A; WarrantyDescription: N/A; ModelReference: FE710DRS; SustainabilityPerformance: N/A
Constraints - Level: Level: Level 1; Host: Level : Level 1; Moves With Nearby Elements: no
Phasing - Phase Created: New Construction
Identity Data - OmniClass Title: Ranges; Manufacturer: SAMSUNG; OmniClass Number: 23.40.40.14.17.17; Model: FE710DRS
Name (M_Range:760 x 650mm:760 x 650mm:...) | Mark
575492 | 61
575493 | 62

# IfcFlowTerminal: 850 x 760mm (2)
In: Level 1
Type - ElementType: 850 x 760mm; PredefinedType: FRIDGE_FREEZER; Classification:  (UniFormat)
Material: Metal - Chrome, Metal - Paint Finish - Ivory, Matte
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no
Other - TagNumber: N/A; AssetIdentifier: N/A; WarrantyStartDate: N/A; BarCode: N/A; SerialNumber: N/A; InstallationDate: N/A; Status: N/A; HasProtectiveEarth: TRUE; Color: N/A; NominalFrequencyRange: 60; WarrantyGuarantorParts: N/A; RatedVoltage: 120; RatedCurrent: 15; Constituents: N/A; Height: 6.00394 ft; NominalWidth: N/A; Features: N/A; NumberOfPoles: 1; Material: Metal - Paint Finish - Ivory, Matte; Width: 2.78871 ft; AssetAccountingType: FIXED; SustainabilityPerformance: N/A; Grade: N/A; WarrantyDurationLabor: N/A; AccessibilityPerformance: N/A; ModelLabel: N/A; WarrantyDescription: N/A; ProductionYear: N/A; Shape: N/A; ModelReference: ED5LHAXWQ; IP_Code: 52; WarrantyGuarantorLabor: N/A; ReplacementCost: N/A; Size: N/A; Finish: N/A; WarrantyDurationParts: N/A; Depth: 2.49344 ft; Label: REF.; ConductorFunction: L3; NominalLength: N/A; PowerFactor: 0.70; InsulationStandardClass: NOTKNOWN; ExpectedLife: N/A; CodePerformance: N/A; NominalHeight: N/A
Phasing - Phase Created: New Construction
Identity Data - OmniClass Number: 23.40.40.11.11.11; Model: ED5LHAXWQ; OmniClass Title: Refrigerators; Manufacturer: SAMSUNG
Name (M_Refrigerator:850 x 760mm:850 x 760mm:...) | Mark
575374 | 1
575375 | 2

# IfcFlowTerminal: Duplex Receptacle (47)
Type - ElementType: Duplex Receptacle; PredefinedType: POWEROUTLET; Classification:  (UniFormat)
Other - WarrantyStartDate: N/A; BarCode: N/A; TagNumber: N/A; InstallationDate: N/A; SerialNumber: N/A; IsPluggableOutlet: TRUE; AssetIdentifier: N/A; Status: NEW; WarrantyGuarantorLabor: N/A; Color: N/A; ModelReference: 5262BLK; HasProtectiveEarth: TRUE; RatedCurrent: 15; NumberOfPoles: 1; WarrantyGuarantorParts: N/A; SustainabilityPerformance: N/A; NominalFrequencyRange: 60; Shape: N/A; Finish: N/A; WarrantyDescription: N/A; WarrantyDurationParts: N/A; ConductorFunction: L1; WarrantyDurationLabor: N/A; AssetAccountingType: FIXED; Constituents: N/A; NominalLength: N/A; Material: N/A; IP_Code: 52; PowerFactor: 0.80; ProductionYear: N/A; ReplacementCost: N/A; AccessibilityPerformance: N/A; NominalHeight: N/A; ExpectedLife: N/A; Features: N/A; InsulationStandardClass: NOTKNOWN; RatedVoltage: 125; CodePerformance: N/A; ModelLabel: N/A; Size: N/A; Grade: N/A; NominalWidth: N/A
Phasing - Phase Created: New Construction
Text - Reference: Type D
Constraints - Offset: 0 ft; Default Elevation: 1.50919 ft
Electrical - Circuiting - Electrical Data: 120 V/1-180 VA
Electrical - Load: 1937.5; Switch Voltage: 1291.67; Load Classification: Receptacle
Identity Data - Model: 5262BLK; Manufacturer: Legrand; Pass & Seymour; OmniClass Number: 23.80.50.11.17; OmniClass Title: Ground Fault Receptacles
Name (M_Duplex Receptacle:Duplex Receptacle:Duplex Receptacle:...) | In | Mark | Host | Elevation (ft) | Circuit Number | Panel
575405 | Level 2 | 9 | Orphaned | 0 | 7 | Unit A Panelboard
575406 | Level 2 | 10 | Orphaned | 0 | 7 | Unit A Panelboard
575407 | Level 2 | 11 | Orphaned | 0 | 7 | Unit A Panelboard
575409 | Level 2 | 12 | Orphaned | 0 | 7 | Unit A Panelboard
575410 | Level 2 | 13 | Orphaned | 0 | 8 | Unit A Panelboard
575419 | Level 2 | 19 | Orphaned | 0 | 6 | Unit B Panelboard
575422 | Level 2 | 21 | Orphaned | 0 | 5 | Unit B Panelboard
575424 | Level 2 | 22 | Orphaned | 0 | 5 | Unit B Panelboard
575425 | Level 2 | 23 | Orphaned | 0 | 5 | Unit B Panelboard
575426 | Level 2 | 24 | Orphaned | 0 | 7 | Unit B Panelboard
575428 | Level 2 | 25 | Orphaned | 0 | 7 | Unit B Panelboard
575430 | Level 2 | 26 | Orphaned | 0 | 6 | Unit A Panelboard
575432 | Level 2 | 27 | Orphaned | 0 | 6 | Unit A Panelboard
575434 | Level 2 | 28 | Orphaned | 0 | 5 | Unit A Panelboard
575435 | Level 2 | 29 | Orphaned | 0 | 5 | Unit A Panelboard
575436 | Level 2 | 30 | Orphaned | 0 | 8 | Unit B Panelboard
575438 | Level 2 | 31 | Orphaned | 0 | 8 | Unit B Panelboard
575439 | Level 2 | 32 | Orphaned | 0 | 8 | Unit B Panelboard
575440 | Level 2 | 33 | Orphaned | 0 | 5 | Unit A Panelboard
575441 | Level 1 | 35 | Orphaned | 0 | 2 | Unit B Panelboard
575442 | Level 1 | 36 | Orphaned | 0 | 1 | Unit B Panelboard
575444 | Level 1 | 37 | Orphaned | 0 | 1 | Unit B Panelboard
575445 | Level 1 | 38 | Orphaned | 0 | 1 | Unit B Panelboard
575446 | Level 1 | 39 | Orphaned | 0 | 4 | Unit B Panelboard
575448 | Level 1 | 40 | Orphaned | 0 | 4 | Unit B Panelboard
575449 | Level 1 | 41 | Orphaned | 0 | 3 | Unit B Panelboard
575451 | Level 1 | 43 | Orphaned | 0 | 3 | Unit B Panelboard
575454 | Level 1 | 45 | Orphaned | 0 | 1 | Unit A Panelboard
575456 | Level 1 | 47 | Orphaned | 0 | 1 | Unit A Panelboard
575460 | Level 1 | 49 | Orphaned | 0 | 2 | Unit B Panelboard
575462 | Level 1 | 50 | Orphaned | 0 | 2 | Unit B Panelboard
575464 | Level 1 | 51 | Orphaned | 0 | 3 | Unit A Panelboard
575466 | Level 1 | 52 | Orphaned | 0 | 3 | Unit A Panelboard
575468 | Level 1 | 53 | Orphaned | 0 | 3 | Unit A Panelboard
575469 | Level 1 | 54 | Orphaned | 0 | 4 | Unit A Panelboard
575470 | Level 1 | 55 | Orphaned | 0 | 4 | Unit A Panelboard
575471 | Level 1 | 56 | Orphaned | 0 | 4 | Unit A Panelboard
575473 | Level 1 | 57 | Orphaned | 0 | 2 | Unit A Panelboard
575475 | Level 1 | 58 | Orphaned | 0 | 2 | Unit A Panelboard
575476 | Level 1 | 59 | Orphaned | 0 | 2 | Unit A Panelboard
575477 | Level 1 | 60 | Orphaned | 0 | 4 | Unit B Panelboard
575494 | Level 1 | 63 | Orphaned | 0 | 2 | Unit B Panelboard
575495 | Level 1 | 64 | Orphaned | 0 | 3 | Unit A Panelboard
606293 | Level 1 | 3 | <not associated> | 0 | 3 | Unit A Panelboard
606323 | Level 1 | 4 | <not associated> | 0 | 2 | Unit B Panelboard
615696 | Level 1 | 14 | Linked Revit Model : Duplex_A_2013.rvt | 5.57743 | 3 | Unit A Panelboard | Other - Schedule Level: Level: Level 1
615756 | Level 1 | 15 | Linked Revit Model : Duplex_A_2013.rvt | 5.57743 | 2 | Unit B Panelboard | Other - Schedule Level: Level: Level 1

# IfcFlowTerminal: Single Pole (14)
Type - ElementType: Single Pole; PredefinedType: USERDEFINED; Classification:  (UniFormat)
Other - BarCode: N/A; AssetIdentifier: N/A; TagNumber: N/A; WarrantyStartDate: N/A; SerialNumber: N/A; InstallationDate: N/A; NominalLength: N/A; Shape: N/A; WarrantyGuarantorLabor: N/A; NominalWidth: N/A; Finish: N/A; ReplacementCost: N/A; NominalHeight: N/A; ProductionYear: N/A; ExpectedLife: N/A; Size: N/A; ConductorFunction: L1; Grade: N/A; NumberOfPoles: 1; Features: N/A; ModelReference: ABC; IP_Code: 52; HasProtectiveEarth: TRUE; SustainabilityPerformance: N/A; CodePerformance: N/A; RatedCurrent: 20; PowerFactor: 0.90; AssetAccountingType: FIXED; NominalFrequencyRange: 60; Constituents: N/A; WarrantyDurationLabor: N/A; ModelLabel: N/A; WarrantyDurationParts: N/A; Material: N/A; AccessibilityPerformance: N/A; WarrantyDescription: N/A; RatedVoltage: 120; Color: N/A; WarrantyGuarantorParts: N/A
Electrical - Switch Voltage: 1291.67; Load Classification: Other
Phasing - Phase Created: New Construction
Constraints - Elevation: 0 ft; Offset: 0 ft; Host: Orphaned; Default Elevation: 3.93701 ft
Electrical - Circuiting - Electrical Data: 120 V/1-0 VA
Identity Data - Manufacturer: Hampton Bay; OmniClass Title: Switches; OmniClass Number: 23.80.50.11.14; Model: ABC
Electrical - Loads - Apparent Load: 0
Name (M_Lighting Switches:Single Pole:Single Pole:...) | In | Panel | Circuit Number
575392 | Level 2 | Unit A Panelboard | 7
575394 | Level 2 | Unit B Panelboard | 5
575396 | Level 2 | Unit B Panelboard | 6
575398 | Level 2 | Unit A Panelboard | 8
575400 | Level 2 | Unit B Panelboard | 8
575402 | Level 2 | Unit A Panelboard | 5
575478 | Level 1 | Unit A Panelboard | 2
575483 | Level 1 | Unit A Panelboard | 4
575484 | Level 1 | Unit A Panelboard | 1
575485 | Level 1 | Unit B Panelboard | 3
575486 | Level 1 | Unit B Panelboard | 1
575487 | Level 1 | Unit B Panelboard | 4
575507 | Level 2 | Unit A Panelboard | 6
575510 | Level 2 | Unit B Panelboard | 7

# IfcFlowTerminal: TTB 300x300, M_Telephone Terminal Board:TTB 300x300:TTB1:618690
In: Level 1
Type - ElementType: TTB 300x300; PredefinedType: USERDEFINED; Classification:  (UniFormat)
Constraints - Default Elevation: 3.93701 ft; HalfWidth: 0.492126 ft; HalfHeight: 0.492126 ft; Elevation: 3.93701 ft; Host: Linked Revit Model : Duplex_A_2013.rvt
Dimensions - Depth: 0.062336 ft; Standoff: 0.082021 ft; Height: 0.984252 ft; Width: 0.984252 ft
Identity Data - OmniClass Title: Intercommunication Equipment; OmniClass Number: 23.85.50.14.21; Manufacturer: Terminal Block; Model: XYZ; Mark: 2
Other - PowerFactor: 0.88; Color: N/A; Shape: N/A; Grade: N/A; NominalLength: N/A; InsulationStandardClass: NOTKNOWN; HasProtectiveEarth: FALSE; NumberOfPoles: 1; WarrantyDescription: N/A; Constituents: N/A; ExpectedLife: N/A; RatedCurrent: 240; IsSkilledOperator: TRUE; Size: N/A; RatedVoltage: 120; WarrantyGuarantorLabor: N/A; AccessibilityPerformance: N/A; ModelReference: XYZ; WarrantyGuarantorParts: N/A; CodePerformance: N/A; Material: N/A; NominalFrequencyRange: 50-60; WarrantyDurationLabor: N/A; SustainabilityPerformance: N/A; IsMain: FALSE; NominalWidth: N/A; Finish: N/A; NominalHeight: N/A; WarrantyDurationParts: N/A; Features: N/A; ProductionYear: N/A; IP_Code: 54; AssetAccountingType: FIXED; ConductorFunction: L1; ModelLabel: N/A; ReplacementCost: N/A; TagNumber: N/A; BarCode: N/A; AssetIdentifier: N/A; SerialNumber: N/A; Schedule Level: Level: Level 1; Status: NEW; WarrantyStartDate: N/A; InstallationDate: N/A
General - Panel Name: TTB1
Phasing - Phase Created: New Construction
Text - Reference: Type E
